Properties of the parts of a building model (IFC4X1)

# File
Time: 2024-02-22T10:46:41
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuilding (19)
Description: Created by Civil Site Design
Name
Pavement
Topsoil
CorazzamentoConMassi
NONE
Grass
2 x PennelloScheda8/LSL/LAL/1/CorazzamentoConMassi
2 x PennelloScheda8/C.L./LST/1/CorazzamentoConMassi
2 x PennelloScheda8/C.L./RST/1/CorazzamentoConMassi
2 x PennelloScheda8/LST/LAT/1/CorazzamentoConMassi
2 x PennelloScheda8/LAT/LSL/1/CorazzamentoConMassi
2 x PennelloScheda8/RAT/RSR/1/CorazzamentoConMassi
2 x PennelloScheda8/RST/RAT/1/CorazzamentoConMassi

# IfcBuildingElementProxy (19)
Description: Created by Civil Site Design
Name | In | String Name | Code 1 | Code 2 | Layer Index | Material
Pavement | Pavement
Topsoil | Topsoil
CorazzamentoConMassi | CorazzamentoConMassi
NONE | NONE
Grass | Grass
2 x PennelloScheda8/LSL/LAL/1/CorazzamentoConMassi | PennelloScheda8/LSL/LAL/1/CorazzamentoConMassi | PennelloScheda8 | LSL | LAL | 1 | CorazzamentoConMassi
2 x PennelloScheda8/C.L./LST/1/CorazzamentoConMassi | PennelloScheda8/C.L./LST/1/CorazzamentoConMassi | PennelloScheda8 | C.L. | LST | 1 | CorazzamentoConMassi
2 x PennelloScheda8/C.L./RST/1/CorazzamentoConMassi | PennelloScheda8/C.L./RST/1/CorazzamentoConMassi | PennelloScheda8 | C.L. | RST | 1 | CorazzamentoConMassi
2 x PennelloScheda8/LST/LAT/1/CorazzamentoConMassi | PennelloScheda8/LST/LAT/1/CorazzamentoConMassi | PennelloScheda8 | LST | LAT | 1 | CorazzamentoConMassi
2 x PennelloScheda8/LAT/LSL/1/CorazzamentoConMassi | PennelloScheda8/LAT/LSL/1/CorazzamentoConMassi | PennelloScheda8 | LAT | LSL | 1 | CorazzamentoConMassi
2 x PennelloScheda8/RAT/RSR/1/CorazzamentoConMassi | PennelloScheda8/RAT/RSR/1/CorazzamentoConMassi | PennelloScheda8 | RAT | RSR | 1 | CorazzamentoConMassi
2 x PennelloScheda8/RST/RAT/1/CorazzamentoConMassi | PennelloScheda8/RST/RAT/1/CorazzamentoConMassi | PennelloScheda8 | RST | RAT | 1 | CorazzamentoConMassi
