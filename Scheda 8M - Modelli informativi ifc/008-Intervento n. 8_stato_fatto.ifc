Properties of the parts of a building model (IFC4X1)

# File
Time: 2024-03-07T13:34:21
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcBuilding, Grass
Description: Created by Civil Site Design

# IfcBuildingElementProxy, Grass
In: Grass
Description: Created by Civil Site Design
